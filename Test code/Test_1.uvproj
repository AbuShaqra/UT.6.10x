# Keil uVision project Test_1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1230C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Test_1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c startup.s
  group Headers
    ./: PortF_Init.h
